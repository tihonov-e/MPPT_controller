# Keil uVision project mppt_controller.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mppt_controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\CMSIS\Device\ST\STM32F30x\Source;.\CMSIS\Device\ST\STM32F30x\Include;.\CMSIS\Include;.\STM32F30x_StdPeriph_Driver\inc;.\STM32F30x_StdPeriph_Driver\src;.\STM32F30x_StdPeriph_Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./User/: main.c
    ./STM32F30x_StdPeriph_Driver/: stm32f30x_conf.h
  group CMSIS
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group Startup
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f334x8.s
  group StdPeriph
    ./STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_usart.c
software components: Device:Startup 1.0.0
